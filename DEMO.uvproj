# Keil uVision project DEMO.uvproj, settings and files
target DEMO (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group user
    ./src/: main.c delay.c cpu.c comm.c control.c
  group startup
    ./src/: STARTUP.A51
  group device
    ./src/: 1602.c DHT11.c ds1302.c uart.c irda.c EEPROM.c ADC.c
